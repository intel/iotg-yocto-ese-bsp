THP_KERNEL_COMMON_ARGS = "hugepages=1024"
