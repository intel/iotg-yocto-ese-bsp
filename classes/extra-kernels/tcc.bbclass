TCC_KERNEL_COMMON_ARGS = "iommu=pt rdt=!l3cat,!l2cat nohz=1-3 nohz_full=1-3 art=virtallow"
