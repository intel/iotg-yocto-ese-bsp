# enable slimboot images
COMPLEMENTARY_GLOB[slimboot] = "*kernel-image-sblimage"
KERNEL_CLASSES:append = " kernel-sblimage"
