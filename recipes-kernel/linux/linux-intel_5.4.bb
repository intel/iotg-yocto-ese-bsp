# stub recipe
require linux-intel-ese-lts-5.4_git.bb
